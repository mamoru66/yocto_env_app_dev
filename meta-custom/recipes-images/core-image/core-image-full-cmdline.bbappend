IMAGE_INSTALL:remove = "rpi-module-loader"
IMAGE_INSTALL:append = " my-settings"