
LICENSE = "MIT"

IMAGE_INSTALL += " \
    python3-platformdirs \
    python3-yfinance \
"